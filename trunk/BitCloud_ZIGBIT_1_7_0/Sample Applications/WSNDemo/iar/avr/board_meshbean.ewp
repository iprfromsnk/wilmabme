# IAR project board_meshbean.ewp, settings and files
configuration All_ZigBit_Atmega1281_Rf230_8Mhz (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: STACK_TYPE_ALL; SECURITY_MODE_NONE; BOARD_MESHBEAN; ATMEGA1281; AT86RF230; HAL_8MHz
  ICCAVR.CCDiagSuppress: Pa050, Pe188
  ICCAVR.newCCIncludePaths: ..\..\include; ..\..\..\..\BitCloud\Components\APS\include; ..\..\..\..\BitCloud\Components\SystemEnvironment\include; ..\..\..\..\BitCloud\Components\HAL\include; ..\..\..\..\BitCloud\Components\HAL\drivers\include; ..\..\..\..\BitCloud\Components\HAL\drivers\VCP\include; ..\..\..\..\BitCloud\Components\NWK\include; ..\..\..\..\BitCloud\Components\NWK\include\private; ..\..\..\..\BitCloud\Components\MAC_PHY\include; ..\..\..\..\BitCloud\Components\ZDO\include; ..\..\..\..\BitCloud\Components\ConfigServer\include; ..\..\..\..\BitCloud\Components\BSP\include; ..\..\..\..\BitCloud\Components\BSP; ..\..\..\..\BitCloud\Components\PersistDataServer\include; ..\..\..\..\BitCloud\Components\MAC_PHY\MAC_HWI\include; ..\..\..\..\BitCloud\Components\MAC_PHY\include; ..\..\..\..\BitCloud\Components\MAC_PHY\MAC_ENV\include; ..\..\..\..\BitCloud\Components\MAC_PHY\MAC_HWD_PHY\include; ..\..\..\..\BitCloud\Components\Security\ServiceProvider\include; ..\..\..\..\BitCloud\Components\Security\TrustCentre\include; ..\..\..\..\BitCloud\lib; ..\..\..\..\BitCloud\Components\BSP\MESHBEAN\include; ..\..\..\..\BitCloud\Components\HAL\avr\atmega1281\common\include; ..\..\..\..\BitCloud\Components\HAL\avr\atmega1281\zigBit\include; ..\..\..\..\BitCloud\Components\MAC_PHY\MAC_HWD_PHY\RF230\PHY\include; ..\..\..\..\BitCloud\Components\MAC_PHY\MAC_HWD_PHY\RF230\MAC_HWD\include
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICCAVR.PreInclude: ..\iarConfiguration.h
  XLINK.XExtraOptions: -f ..\..\linkerScr\cfgm1281bitcloud.xcl; ..\..\..\..\BitCloud\lib\libBc_All_ZigBit_Atmega1281_Rf230_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\libHal_ZigBit_Atmega1281_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\WdtInitatmega1281Iar.o
configuration All_Sec_ZigBit_Atmega1281_Rf230_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: STACK_TYPE_ALL; SECURITY_MODE_STANDART; BOARD_MESHBEAN; ATMEGA1281; AT86RF230; HAL_8MHz
  XLINK.XExtraOptions: -f ..\..\linkerScr\cfgm1281bitcloud.xcl; ..\..\..\..\BitCloud\lib\libBc_All_Sec_ZigBit_Atmega1281_Rf230_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\libHal_ZigBit_Atmega1281_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\WdtInitatmega1281Iar.o
configuration Coordinator_ZigBit_Atmega1281_Rf230_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: STACK_TYPE_COORDINATOR; SECURITY_MODE_NONE; BOARD_MESHBEAN; ATMEGA1281; AT86RF230; HAL_8MHz
  XLINK.XExtraOptions: -f ..\..\linkerScr\cfgm1281bitcloud.xcl; ..\..\..\..\BitCloud\lib\libBc_Coordinator_ZigBit_Atmega1281_Rf230_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\libHal_ZigBit_Atmega1281_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\WdtInitatmega1281Iar.o
configuration Coordinator_Sec_ZigBit_Atmega1281_Rf230_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: STACK_TYPE_COORDINATOR; SECURITY_MODE_STANDART; BOARD_MESHBEAN; ATMEGA1281; AT86RF230; HAL_8MHz
  XLINK.XExtraOptions: -f ..\..\linkerScr\cfgm1281bitcloud.xcl; ..\..\..\..\BitCloud\lib\libBc_Coordinator_Sec_ZigBit_Atmega1281_Rf230_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\libHal_ZigBit_Atmega1281_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\WdtInitatmega1281Iar.o
configuration Router_ZigBit_Atmega1281_Rf230_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: STACK_TYPE_ROUTER; SECURITY_MODE_NONE; BOARD_MESHBEAN; ATMEGA1281; AT86RF230; HAL_8MHz
  XLINK.XExtraOptions: -f ..\..\linkerScr\cfgm1281bitcloud.xcl; ..\..\..\..\BitCloud\lib\libBc_Router_ZigBit_Atmega1281_Rf230_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\libHal_ZigBit_Atmega1281_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\WdtInitatmega1281Iar.o
configuration Router_Sec_ZigBit_Atmega1281_Rf230_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: STACK_TYPE_ROUTER; SECURITY_MODE_STANDART; BOARD_MESHBEAN; ATMEGA1281; AT86RF230; HAL_8MHz
  XLINK.XExtraOptions: -f ..\..\linkerScr\cfgm1281bitcloud.xcl; ..\..\..\..\BitCloud\lib\libBc_Router_Sec_ZigBit_Atmega1281_Rf230_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\libHal_ZigBit_Atmega1281_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\WdtInitatmega1281Iar.o
configuration EndDevice_ZigBit_Atmega1281_Rf230_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: STACK_TYPE_ENDDEVICE; SECURITY_MODE_NONE; BOARD_MESHBEAN; ATMEGA1281; AT86RF230; HAL_8MHz
  XLINK.XExtraOptions: -f ..\..\linkerScr\cfgm1281bitcloud.xcl; ..\..\..\..\BitCloud\lib\libBc_EndDevice_ZigBit_Atmega1281_Rf230_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\libHal_ZigBit_Atmega1281_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\WdtInitatmega1281Iar.o
configuration EndDevice_Sec_ZigBit_Atmega1281_Rf230_8Mhz (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: STACK_TYPE_ENDDEVICE; SECURITY_MODE_STANDART; BOARD_MESHBEAN; ATMEGA1281; AT86RF230; HAL_8MHz
  XLINK.XExtraOptions: -f ..\..\linkerScr\cfgm1281bitcloud.xcl; ..\..\..\..\BitCloud\lib\libBc_EndDevice_Sec_ZigBit_Atmega1281_Rf230_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\libHal_ZigBit_Atmega1281_8Mhz_Iar.a; ..\..\..\..\BitCloud\lib\WdtInitatmega1281Iar.o
  group configuration
    ../: iarConfiguration.h
  group src
    ../../src/: WSNCoord.c WSNDemoApp.c WSNEndDevice.c WSNRouter.c WSNSensorManager.c WSNUARTManager.c WSNVisualizer.c
  group include
    ../../include/: serialInterface.h WSNDemoApp.h WSNVisualizer.h
  group Components/ConfigServer/src
    ../../../../BitCloud/Components/ConfigServer/src/: configServer.c
  group Components/ConfigServer/include
    ../../../../BitCloud/Components/ConfigServer/include/: configServer.h
  group Components/PersistDataServer/src
    ../../../../BitCloud/Components/PersistDataServer/src/: pdsCrcService.c pdsDataServer.c pdsWriteData.c
  group Components/PersistDataServer/include
    ../../../../BitCloud/Components/PersistDataServer/include/: pdsAuxService.h pdsCrcService.h pdsDataServer.h pdsMemAbstract.h
  group Components/BSP/src
    ../../../../BitCloud/Components/BSP/MESHBEAN/src/: battery.c bspTaskManager.c buttons.c leds.c lm73.c pwrCtrl.c sensors.c sliders.c tsl2550.c
  group Components/BSP/include
    ../../../../BitCloud/Components/BSP/MESHBEAN/include/: battery.h bspLeds.h bspTaskManager.h lm73.h pwrCtrl.h tsl2550.h
  group Components/BSP/common
    ../../../../BitCloud/Components/BSP/include/: buttons.h hexSwitch.h joystick.h lcd.h leds.h rs232Controller.h rs485Controller.h sensors.h sliders.h usbController.h
