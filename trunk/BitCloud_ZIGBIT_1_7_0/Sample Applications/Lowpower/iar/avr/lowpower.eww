<workspace>
  <batchBuild/>
<project><path>$WS_DIR$\board_meshbean.ewp</path></project></workspace>